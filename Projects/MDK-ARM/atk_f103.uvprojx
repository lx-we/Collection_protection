# Keil uVision project atk_f103.uvprojx, settings and files
target DHT11 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\User;..\..\Middlewares;..\..\Common
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/DHT11/: dht11.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/LOCK/: lock.c
    ../../Drivers/BSP/SR602/: sr602.c
    ../../Drivers/BSP/SW-18010P/: sw.c
    ../../Drivers/BSP/LED-WS2812/: ws.c
    ../../Drivers/BSP/TIMER/: btim.c gtim.c
    ../../Drivers/BSP/WIRELESS/: driver_wireless.c driver_wireless.h
  group Readme
    ../../: readme.txt
  group Common
    ../../Common/: cJSON.c cJSON.h
